# Keil uVision project JAT1821.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: Debug
  c flags: oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM4,__TARGET_FPU_VFP,__DEBUG
  c misc: --no-multibyte-chars
  c include: ..\source\core\;..\source\hal\inc\;..\source\startup\;..\source\main\;..\source\rtos\;..\source\app\;..\source\driver\;..\source\driver\uart;..\source\driver\i2c;..\source\driver\spi;..\source\driver\drv_key;..\source\driver\dual_timer;..\source\driver\pwm;..\source\driver\test_drv;..\source\driver\dma;..\source\demo;..\source\driver\usb\uac10;..\source\driver\usb\uac10\headers;..\source\driver\alg\;..\source\driver\alg\dsp;..\source\driver\alg\dsp\Headers;..\source\driver\alg\src\Headers;..\source\driver\user_memory;..\source\driver\alg\dsp\alg_para_default;..\source\hal\headers;..\source\user;..\source\user\PeriphConfig;..\source\user\FirmwareUpgrade;..\source\user\Dsp;..\source\user\Comm;..\source\user\Helper;..\source\user\Memory;..\source\user\Ui;..\source\user\ParamTable;..\source\driver\alg\dsp\enc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x28000000 size 0x20000
  scatter file: .\JAT1821.sct
  group User
    ../source/user/: ProjectConfig.h
  group FwUpgrade
    ../source/user/FirmwareUpgrade/: Fw.Upgrade.c Fw.Info.c Fw.Version.h Fw.DfuStatusBytes.c
    ../../Bootloader/Tools/: Fw.BlCode.c
  group PeriphCfg
    ../source/user/PeriphConfig/: OsTick.c Gpio.c Crc.c Iap.c Spi.c Hid.c
  group Dsp
    ../source/user/Dsp/: Dsp.c Dsp.Config.c Dsp.Program.c Dsp.Program.ModuleTable.c Dsp.Driver.c
  group ParamTable
    ../source/user/ParamTable/: ParamTable.c ParamTable.h ParamTable.DevInfo.c ParamTable.DevInfo.h ParamTable.Config.c ParamTable.Config.h ParamTable.Preset.c ParamTable.Preset.h
  group Ui
    ../source/user/Ui/: Ui.c Ui.h Ui.Key.c Ui.Key.h Ui.Led.c Ui.Led.h
  group Memory
    ../source/user/Memory/: Memory.c Memory.h Mem.Driver.c Mem.Driver.h Mem.SaveLoad.c Mem.SaveLoad.h
  group Comm
    ../source/user/Comm/: Com.c Com.HidRx.c Com.DataProcess.c
  group Helper
    ../source/user/Helper/: Helper.c Helper.h
  group startup
    ../source/startup/: system_a0.c startup_a0.s
    ./: JAT1821.sct A0.bat
  group main
    ../source/main/: dwt_itm.c main.c Initial.c UserFunction.c a0_it.c Timer.c
  group app
    ../source/app/: app_i2s.c app_dma.c app_codec.c app_i2s_resample.c
  group demo&test_drv
    ../source/driver/: conf_demo_or_test.h
    ../source/driver/test_drv/: test_drv_readme.txt test_drv.c
    ../source/demo/: demo_readme.txt demo.c
  group driver
    ../source/driver/: drv_readme.txt conf_drv_en.h
    ../source/driver/uart/: drv_uart.c
    ../source/driver/spi/: drv_spi_std.c drv_spi_std_slave.c
    ../source/driver/i2c/: drv_i2c_master.c drv_i2c_slave.c
    ../source/driver/drv_key/: drv_key_adc.c drv_key_io.c
    ../source/driver/pwm/: drv_pwm.c
    ../source/driver/dual_timer/: drv_dual_timer.c
    ../source/driver/dma/: drv_dma.c
    ../source/driver/user_memory/: user_memery.c
  group driver_usb_new
    ../source/driver/usb/uac10/: drv_uac10.c drv_uac10.lib UsbUserInfoSet.c drv_uac10_lib.c
  group driver_alg
    ../source/driver/alg/dsp/: drv_alg.c drv_alg.lib mcu_alg_comp.c mcu_alg_limiter.c
    ../source/driver/alg/src/: jat_resample.lib
    ../source/driver/alg/dsp/enc/: fast_math.c enc.c histograms.c noise_estimator.c noise_suppressor.c prior_signal_model.c prior_signal_model_estimator.c quantile_noise_estimator.c signal_model.c signal_model_estimator.c speech_probability_estimator.c suppression_params.c three_band_filter_bank.c wiener_filter.c
  group hal
    ../source/hal/inc/: a0_hal_conf.h
    ../source/hal/src/: a0_hal_sys_ctrl.c a0_hal_otg_device.c a0_hal_dma.c a0_hal_i2s.c a0_hal_kbd.c a0_hal_uart.c a0_hal_timer.c a0_hal_i2c_master.c a0_hal_i2c_slave.c a0_hal_pwm.c a0_hal_spi_std.c a0_hal_gpio.c a0_hal_otg_host.c
    ../source/hal/src//: a0_hal_spi_flash.c a0_hal_adc.c
    ../source/hal/: agent.lib
  group core
    ../source/core/: arm_cortexM4lf_math.lib
target Release_Dfu (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.4.0
  cpu: as above
  output: Release +hex
  BeforeMake: Python "..\Tools\Py\Firmware_4_Version_Build.py"
  AfterMake: Pythonw "..\Tools\Py\Firmware_4_Updater_Build.py"
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM4,__TARGET_FPU_VFP,__RELEASE_DFU
  c misc: --no-multibyte-chars
  c include: ..\source\core\;..\source\hal\inc\;..\source\startup\;..\source\main\;..\source\rtos\;..\source\app\;..\source\driver\;..\source\driver\uart;..\source\driver\i2c;..\source\driver\spi;..\source\driver\drv_key;..\source\driver\dual_timer;..\source\driver\pwm;..\source\driver\test_drv;..\source\driver\dma;..\source\demo;..\source\driver\usb\uac10;..\source\driver\usb\uac10\headers;..\source\driver\alg\;..\source\driver\alg\dsp;..\source\driver\alg\dsp\Headers;..\source\driver\alg\src\Headers;..\source\driver\user_memory;..\source\driver\alg\dsp\alg_para_default;..\source\hal\headers;..\source\user;..\source\user\PeriphConfig;..\source\user\FirmwareUpgrade;..\source\user\Dsp;..\source\user\Comm;..\source\user\Helper;..\source\user\Memory;..\source\user\Ui;..\source\user\ParamTable
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\JAT1821.sct
target Release_Hex (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.4.0
  cpu: as above
  output: Release +hex
  BeforeMake: Python "..\Tools\Py\Firmware_4_Version_Build.py"
  AfterMake: Pythonw "..\Tools\Py\Firmware_4_Factory_Build.py"
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM4,__TARGET_FPU_VFP,__RELEASE_HEX
  c include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\JAT1821.sct
