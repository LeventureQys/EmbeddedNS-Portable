# Keil uVision project JAT1821.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: Debug
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM4,__TARGET_FPU_VFP,__DEBUG
  c include: ..\source\core\;..\source\hal\inc\;..\source\startup\;..\source\main\;..\source\rtos\;..\source\app\;..\source\driver\;..\source\driver\uart;..\source\driver\i2c;..\source\driver\spi;..\source\driver\drv_key;..\source\driver\dual_timer;..\source\driver\pwm;..\source\driver\test_drv;..\source\driver\dma;..\source\demo;..\source\driver\usb\uac10;..\source\driver\usb\uac10\headers;..\source\driver\alg\;..\source\driver\alg\dsp;..\source\driver\alg\dsp\Headers;..\source\driver\alg\src\Headers;..\source\driver\user_memory;..\source\driver\alg\dsp\alg_para_default;..\source\hal\headers;..\source\user;..\source\user\PeriphConfig;..\source\user\FirmwareUpgrade;..\source\user\Dsp;..\source\user\Comm;..\source\user\Helper;..\source\user\Memory;..\source\user\Ui;..\source\user\ParamTable
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\JAT1821.sct
  group User
    ../source/user/: ProjectConfig.h SctConfig.h
  group PeriphCfg
    ../source/user/PeriphConfig/: OsTick.c Gpio.c Crc.c Iap.c Spi.c Hid.c
  group Dfu
    ../source/user/FirmwareUpgrade/: Dfu.Core.c Dfu.Core.h Dfu.Encrypt.c Dfu.Program.c Dfu.Program.h Fw.DfuStatusBytes.c Fw.Info.c
  group ParamTable
    ../source/user/ParamTable/: ParamTable.c ParamTable.h
  group Ui
    ../source/user/Ui/: Ui.c Ui.h Ui.Led.c Ui.Led.h
  group Comm
    ../source/user/Comm/: Com.c Com.HidRx.c Com.DataProcess.c
  group startup
    ../source/startup/: system_a0.c startup_a0.s
    ./: JAT1821.sct A0.bat
  group main
    ../source/main/: main.c Initial.c UserFunction.c a0_it.c Timer.c
  group driver_usb_new
    ../source/driver/usb/uac10/: drv_uac10.c drv_uac10.lib UsbUserInfoSet.c drv_uac10_lib.c
  group hal
    ../source/hal/inc/: a0_hal_conf.h
    ../source/hal/src/: a0_hal_sys_ctrl.c a0_hal_otg_device.c a0_hal_dma.c a0_hal_i2s.c a0_hal_kbd.c a0_hal_uart.c a0_hal_timer.c a0_hal_i2c_master.c a0_hal_i2c_slave.c a0_hal_pwm.c a0_hal_spi_std.c a0_hal_gpio.c a0_hal_otg_host.c
    ../source/hal/src//: a0_hal_spi_flash.c a0_hal_adc.c
    ../source/hal/: agent.lib
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.4.0
  cpu: as above
  output: Release +hex
  AfterMake: Python ..\Tools\Hex_2_C_Code.py
  AfterMake: Pythonw "..\Tools\Py\Firmware_4_BootUpdater_Build.py
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM4,__TARGET_FPU_VFP,__RELEASE
  c include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\JAT1821.sct
